# Keil uVision project FTC_Hexacopter.uvproj, settings and files
target FTC_Hexacopter (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: FTC_Hexacopter +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c misc: --cpp
  c include: .\applications;.\drivers;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\Math
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group FtcCopter
    ./applications/: FtcCopter.cpp FTC_Config.cpp FTC_Config.h FTC_DT.cpp FTC_DT.h FTC_Filter.cpp FTC_Filter.h FTC_FlyControl.cpp FTC_FlyControl.h FTC_IMU.cpp FTC_IMU.h FTC_Motor.cpp FTC_Motor.h FTC_Navgation.cpp FTC_Navgation.h FTC_Param.cpp FTC_Param.h FTC_PID.cpp FTC_PID.h FTC_RC.cpp FTC_RC.h FTC_Scheduler.cpp FTC_Scheduler.h
  group Math
    ./Math/: FTC_Math.cpp FTC_Math.h FTC_Matrix3.cpp FTC_Matrix3.h FTC_Quaternion.cpp FTC_Quaternion.h FTC_Rotations.h FTC_Vector3.cpp FTC_Vector3.h
  group Drivers
    ./drivers/: board.c board.h FTC_Drv_ADC.c FTC_Drv_ADC.h FTC_Drv_EEPROM.c FTC_Drv_EEPROM.h FTC_Drv_I2C_soft.cpp FTC_Drv_I2C_soft.h FTC_Drv_LED.cpp FTC_Drv_LED.h FTC_Drv_MPU6050.cpp FTC_Drv_MPU6050.h FTC_Drv_MS5611.cpp FTC_Drv_MS5611.h FTC_Drv_Nrf24l01.cpp FTC_Drv_Nrf24l01.h FTC_Drv_PWM.cpp FTC_Drv_PWM.h FTC_Drv_SPI2.cpp FTC_Drv_SPI2.h FTC_Drv_Uart3.cpp FTC_Drv_Uart3.h stm32f10x_it.c
  group STM32_FWlib
    ./drivers/: stm32f10x_conf.h
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
